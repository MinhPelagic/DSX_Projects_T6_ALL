# IAR project DSX.ewp, settings and files
configuration DSX (ARM, debug)
  General.OGChipSelectEditMenu: STM32L4S9AI ST STM32L4S9AI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: BUILD_DSX; USE_HAL_DRIVER; USE_FULL_LL_DRIVER; STM32L4S9xx
  ICCARM.CCIncludePath2: ../Kernel/Inc; ../DSX; ../TickHandler; ../UserInterface; ../UserInterface/ButtonHandle; ../Libraries/Drivers/STM32L4xx_HAL_Driver/Inc; ../Libraries/Drivers/STM32L4xx_HAL_Driver/Inc/Legacy; ../Libraries/Drivers/CMSIS/Device/ST/STM32L4xx/Include; ../Libraries/Drivers/CMSIS/Include; ../Libraries/Drivers/CSTM_MCU_Drivers; ../Libraries/Drivers/CSTM_PER_Drivers; ../Libraries/Middleware/STemWin; ../Libraries/Middleware/STemWin\Config; ../Libraries/Middleware/STemWin\inc; ../Libraries/Middleware/STemWin\Lib; ../Libraries/Middleware/STemWin\OS; ../Libraries/Middleware/TimeDate; ../Libraries/Middleware/Ambiental; ../Libraries/Middleware/ECompass; ../Libraries/Middleware/Gnss; ../Libraries/Middleware/O2Analyzer; ../Libraries/Middleware/TMT_Receiver; ../Libraries/Middleware/WayFinder; ../Libraries/Middleware/Slates; ../Libraries/Middleware/ALS; ../Libraries/Middleware/STM32_MotionMC_Library/inc; ../Libraries/Middleware/STM32_MotionMC_Library/Lib; ../Libraries/Middleware/STM32_MotionEC_Library/inc; ../Libraries/Middleware/STM32_MotionEC_Library/Lib; ../Libraries/FwUpdate; ../UserInterface/ButtonHandle; ../UserInterface/GUI; ../UserInterface/GUI/LangTextString; ../Libraries/Deco; ../src; ../PelagicLib/include; ../IOsonata/ARM/ST/STM32L4xx/include; ../IOsonata/ARM/include; ../IOsonata/ARM/CMSIS/Core/Include; ../IOsonata/include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: DSX.hex
  ILINK.IlinkOutputFile: DSX.out
  ILINK.IlinkIcfFile: stm32l4s9xx_flash.icf
  ILINK.IlinkAdditionalLibs: ../IOsonata/ARM/ST/STM32L4xx/STM32L4S9/lib/IAR/Release/IOsonata_STM32L4S9.a; ../PelagicLib/STM32L4S9/IAR/Release/PelagicLib_STM32L4S9.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration DSX_BTL (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: BUILD_DSX; BUILD_BTL; USE_HAL_DRIVER; USE_FULL_LL_DRIVER; STM32L4S9xx
  ICCARM.CCIncludePath2: ../Kernel/Inc; ../DSX; ../TickHandler; ../UserInterface; ../UserInterface/ButtonHandle; ../Libraries/Drivers/STM32L4xx_HAL_Driver/Inc; ../Libraries/Drivers/STM32L4xx_HAL_Driver/Inc/Legacy; ../Libraries/Drivers/CMSIS/Device/ST/STM32L4xx/Include; ../Libraries/Drivers/CMSIS/Include; ../Libraries/Drivers/CSTM_MCU_Drivers; ../Libraries/Drivers/CSTM_PER_Drivers; ../Libraries/Middleware/STemWin; ../Libraries/Middleware/STemWin\Config; ../Libraries/Middleware/STemWin\inc; ../Libraries/Middleware/STemWin\Lib; ../Libraries/Middleware/STemWin\OS; ../Libraries/Middleware/TimeDate; ../Libraries/Middleware/Ambiental; ../Libraries/Middleware/ECompass; ../Libraries/Middleware/Gnss; ../Libraries/Middleware/O2Analyzer; ../Libraries/Middleware/GPS; ../Libraries/Middleware/TMT_Receiver; ../Libraries/Middleware/WayFinder; ../Libraries/Middleware/Slates; ../Libraries/Middleware/ALS; ../Libraries/Middleware/STM32_MotionMC_Library/inc; ../Libraries/Middleware/STM32_MotionMC_Library/Lib; ../Libraries/Middleware/STM32_MotionEC_Library/inc; ../Libraries/Middleware/STM32_MotionEC_Library/Lib; ../Libraries/FwUpdate; ../UserInterface/ButtonHandle; ../UserInterface/GUI; ../UserInterface/GUI/LangTextString; ../Libraries/Deco; ../src; ../PelagicLib/include; ../IOsonata/ARM/ST/STM32L4xx/include; ../IOsonata/ARM/include; ../IOsonata/ARM/CMSIS/Core/Include; ../IOsonata/include
  OBJCOPY.OOCOutputFile: DSX_BTL.hex
  ILINK.IlinkIcfFile: stm32l4s9xx_flash_BTL_DSX.icf
  group DSX
    ../DSX/: DSX_Version.h L4X9_Device.h L4X9_hal.h L4X9_Itf.c L4X9_Itf.h
  group EWARM
    ./: startup_stm32l4s9xx.s
  group Kernel
    ../Kernel/Src/: L4X9_ble.c L4X9_misc.c L4X9_NVData.c L4X9_SystemTest.c L4X9_utils.c main.c stm32l4xx_hal_msp.c stm32l4xx_it.c
    ../Kernel/Inc/: L4X9_ble.h L4X9_includes.h L4X9_misc.h L4X9_NVData.h L4X9_SystemTest.h L4X9_utils.h main.h stm32l4xx_it.h
  group Libraries/Deco
    ../Libraries/Deco/: CCOC_DiveAlgo.h CCOC_DiveAlgo.o
  group Libraries/Drivers/CMSIS
    ../Kernel/Src/: system_stm32l4xx.c
  group Libraries/Drivers/CSTM_MCU_Drivers
    ../Libraries/Drivers/CSTM_MCU_Drivers/: STM32L4_MCU_LPUART.c STM32L4_MCU_LPUART.h
  group Libraries/Drivers/CSTM_PER_Drivers
    ../Libraries/Drivers/CSTM_PER_Drivers/: 24CWxxX.c 24CWxxX.h Backlight.c Backlight.h Buzzer.c Buzzer.h CXD5605GF.c CXD5605GF.h LCD_COM24H2P39ULC.c LCD_COM24H2P39ULC.h LSM303AGR.c LSM303AGR.h MAX17262.c MAX77950.c MAX77950.h MS5837_30BA.c MS5837_30BA.h MT25QL512ABB.c MT25QL512ABB.h Vibrator.c
  group Libraries/Drivers/STM32L4xx_HAL_Driver
    ../Libraries/Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dac.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_exti.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_iwdg.c stm32l4xx_hal_lptim.c stm32l4xx_hal_ospi.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_sram.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_usart.c stm32l4xx_hal_usart_ex.c stm32l4xx_ll_dma.c stm32l4xx_ll_exti.c stm32l4xx_ll_fmc.c stm32l4xx_ll_gpio.c stm32l4xx_ll_lptim.c stm32l4xx_ll_lpuart.c stm32l4xx_ll_pwr.c stm32l4xx_ll_rcc.c stm32l4xx_ll_rtc.c stm32l4xx_ll_usb.c
  group Libraries/FwUpdate
    ../Libraries/FwUpdate/: FwUpdate.c FwUpdate.h
  group Libraries/Middleware/ALS
    ../Libraries/Middleware/ALS/: i2c2.c i2c2.h OPT3001.c OPT3001.h
  group Libraries/Middleware/Ambiental
    ../Libraries/Middleware/Ambiental/: Ambiental.o
  group Libraries/Middleware/ECompass
    ../Libraries/Middleware/ECompass/: ECompass.c ECompass.h
  group Libraries/Middleware/Gnss
    ../Libraries/Middleware/GNSS/: Gnss.c Gnss.h GPS_WayFinder.c GPS_WayFinder.h WayFinder.c WayFinder.h
  group Libraries/Middleware/O2Analyzer
    ../Libraries/Drivers/CSTM_PER_Drivers/: adc.c adc.h
    ../Libraries/Middleware/O2Analyzer/: O2.h O2.o
  group Libraries/Middleware/Slates
    ../Libraries/Middleware/Slates/: Slates.c Slates.h
  group Libraries/Middleware/STemwin
    ../Libraries/Middleware/STemWin/OS/: GUI_X.c
    ../Libraries/Middleware/STemWin/Lib/: STemWin_CM4_wc32.a
  group Libraries/Middleware/STemwin/Config
    ../Libraries/Middleware/STemWin/Config/: GUIConf.h GUIConf_DSX.c LCDConf_DSX.c LCDConf_DSX.h
  group Libraries/Middleware/STM32_MotionEC_Library
    ../Libraries/Middleware/STM32_MotionEC_Library/Inc/: motion_ec.h
    ../Libraries/Middleware/STM32_MotionEC_Library/Lib/: MotionEC_CM4F_wc32_ot_hard.a
  group Libraries/Middleware/STM32_MotionMC_Library
    ../Libraries/Middleware/STM32_MotionMC_Library/Inc/: motion_mc.h
    ../Libraries/Middleware/STM32_MotionMC_Library/Lib/: MotionMC_CM4F_wc32_ot_hard.a
  group Libraries/Middleware/TimeDate
    ../Libraries/Middleware/TimeDate/: TimeDate.c TimeDate.h
  group Libraries/Middleware/TMT_Receiver
    ../Libraries/Middleware/TMT_Receiver/: TMT_Receiver.h TMT_Receiver.o
  group src
    ../src/: board.cpp board.h Receiver.cpp Receiver.h
  group TickHandler
    ../TickHandler/: Tick_Handler.c Tick_Handler.h Tick_Handler_0.c Tick_Handler_1.c Tick_Handler_2.c Tick_Handler_3.c Tick_Handler_4.c Tick_Handler_5.c Tick_Handler_6.c Tick_Handler_7.c
  group UserInterface
    ../UserInterface/: app.c app.h
    ../UserInterface/ButtonHandle/: DSX_ButtonHandle.c
  group UserInterface/GUI
    ../UserInterface/GUI/: DSX_Coordinate.c DSX_Data_Decode.c DSX_Data_Process.c DSX_FontStruct.c DsxConditionCheck.c DsxOcConfig.c Icon_DSX.c ShapeDSX.c Text_DSX.c
  group UserInterface/GUI/Bitmaps
    ../UserInterface/GUI/Bitmaps/: DSX manufacturer screen.c DSX_WelcomeBMP.c Register.c USB.c
  group UserInterface/GUI/OC_Handle
    ../UserInterface/GUI/OpcodeHandle/BatteryCharging/: BatteryChargingSleepMode.c
    ../UserInterface/GUI/OpcodeHandle/Menu/Dive Main Menu/SwitchTMTMenu/: ButtonHandle_DiveMainMenu_TMTSwitch.c DiveMainMenu_TMT_Context.c DiveMainMenu_TMTSwitch_MainPage.c
    ../UserInterface/GUI/OpcodeHandle/Menu/Dive Menu/DecoStops/: ButtonHandle_DiveMenu_DecoStop.c Menu_DiveMenu_DecoStops.c Menu_DiveMenu_DecoStops_Context.c MenuHandle_DiveMenu_DecoStop.c
    ../UserInterface/GUI/OpcodeHandle/Menu/Dive Main Menu/ResetAVGDepth/: ButtonHandle_DiveMenu_ResetAvgDepth.c DiveMainMenuHandle_ResetAvgDepth.c
    ../UserInterface/GUI/OpcodeHandle/Menu/Dive Menu/Set GF High/: ButtonHandle_DiveMenu_SetGFHigh.c Menu_DiveMenu_SetGFHigh.c Menu_DiveMenu_SetGFHigh_Context.c MenuHandle_DiveMenu_SetGFHigh.c
    ../UserInterface/GUI/OpcodeHandle/Menu/GPS Menu/: ButtonHandle_GPSMenu_DeleteLocation.c ButtonHandle_GPSMenu_Wayfinder.c ContextGPSMenuCfg.c Menu_GPSMenu_Context_Main.c Menu_GPSMenu_Context_WayFinder.c Menu_GPSMenu_Page_DeleteLocation.c Menu_GPSMenu_Page_DeleteLocationToSaveNew.c Menu_GPSMenu_Page_GoToLocation.c Menu_GPSMenu_Page_InitializingGPS.c Menu_GPSMenu_Page_LocationDeleted.c Menu_GPSMenu_Page_LocationSaved.c Menu_GPSMenu_Page_Main.c Menu_GPSMenu_Page_ReachedTarget.c Menu_GPSMenu_Page_SaveLocation.c Menu_GPSMenu_Page_SignalNotFound.c Menu_GPSMenu_Page_WaitForGpsSignal.c Menu_WayfinderMenu_Context_Main.c Menu_WayfinderMenu_Page_Main.c Menu_WayfinderMenu_Page_MainList.c Mode_GPSMenu_Cfg.c Mode_WayfinderMenu_Cfg.c
    ../UserInterface/GUI/OpcodeHandle/Menu/Main Menu/Main_Menu_LOG/: ButtonHandle_MainMenu_LOG.c Menu_MainMenu_LOG_1.c Menu_MainMenu_LOG_1_Cfg.c Menu_MainMenu_LOG_2.c Menu_MainMenu_LOG_3.c Menu_MainMenu_LOG_4.c Menu_MainMenu_LOG_5.c Menu_MainMenu_LOG_Config.c
    ../UserInterface/GUI/OpcodeHandle/Menu/Main Menu/Main_Menu_TMT_SWITCH/: ButtonHandle_MainMenu_TMTSwitch.c Menu_MainMenu_TMTSwitch_Cfg.c Menu_MainMenu_TMTSwitch_Context.c Menu_MainMenu_TMTSwitch_MainPage.c
    ../UserInterface/GUI/OpcodeHandle/Menu/Set Gases/Set_O2_Analyzer/: ButtonHandle_O2AnalyzerList.c Menu_O2Analyzer_Context_Analyzer_AnalysisResultConfirmation.c Menu_O2Analyzer_Context_Analyzer_Analyzing.c Menu_O2Analyzer_Context_Analyzer_CalibrationWarning.c Menu_O2Analyzer_Context_Analyzer_ConfirmAnalyzerGas.c Menu_O2Analyzer_Context_Analyzer_ReadyAnalyzing.c Menu_O2Analyzer_Context_Analyzer_SelectGasList.c Menu_O2Analyzer_Context_Analyzer_SetFHe.c Menu_O2Analyzer_Context_Calibrate_CalibrationReport.c Menu_O2Analyzer_Context_Calibrate_NoO2AnalyzerFound.c Menu_O2Analyzer_Context_Calibrate_NoO2CellFound.c Menu_O2Analyzer_Context_Calibrate_O2CalibrationComplete.c Menu_O2Analyzer_Context_Calibrate_O2CellDepleted.c Menu_O2Analyzer_Context_Calibrate_ReadingO2Cell.c Menu_O2Analyzer_Context_Calibrate_ReadyCalibaration.c Menu_O2Analyzer_Context_Calibrate_SetPoint.c Menu_O2Analyzer_Context_Main.c Menu_O2Analyzer_Page_Analyzer.c Menu_O2Analyzer_Page_AnalyzerList.c Menu_O2Analyzer_Page_Calibrate.c Menu_O2Analyzer_Page_Main.c Mode_O2Analyzer_Cfg.c
    ../UserInterface/GUI/OpcodeHandle/Surface Mode/: ButtonHandle_SetValueOpcodeSurface.c SurfaceGraph_AscentBar.c SurfaceGraph_Battery.c SurfaceGraph_Bluetooth.c SurfaceGraph_GFBar.c SurfaceGraph_N2Bar.c SurfaceHandle_3rdRowContent_Left.c SurfaceHandle_3rdRowContent_Right.c SurfaceHandle_3rdRowLeftRight.c SurfaceHandle_BottomAlarms.c SurfaceHandle_CC6TankPressure.c SurfaceHandle_CheckBottomDisplay.c SurfaceHandle_ClearPortionScreen.c SurfaceHandle_ColorGTR.c SurfaceHandle_DisplayGTR.c SurfaceHandle_DisplayTimeOnSurfaceCheck.c SurfaceHandle_GaugeCheckDisplayTMT.c SurfaceHandle_LastDiveInformation.c SurfaceHandle_N2orASCBarCheck.c SurfaceHandle_OCLefRightDisplay.c SurfaceHandle_PressureDisplay.c SurfaceHandle_PressureStatusCheck.c SurfaceMode_CC_Alt_1.c SurfaceMode_CC_Alt_2.c SurfaceMode_CC_Alt_3.c SurfaceMode_CC_Alt_4.c SurfaceMode_CC_Alt_5.c SurfaceMode_CC_Main.c SurfaceMode_Cfg.c SurfaceMode_Context.c SurfaceMode_Gauge_Alt_1.c SurfaceMode_Gauge_Alt_2.c SurfaceMode_Gauge_Main.c SurfaceMode_GaugeSM_Main.c SurfaceMode_SM_Alt1.c SurfaceMode_SM_Alt2.c SurfaceMode_SM_Alt3.c SurfaceMode_SM_Alt4.c SurfaceMode_SM_Main.c
    ../UserInterface/GUI/OpcodeHandle/Compass Mode/: Compass_Display_MainValue_Cfg.c Compass_Display_NavigateArrows_Cfg.c Compass_Display_ReferencePoint_Cfg.c Compass_Display_ScaleVerticalBar_Cfg.c Compass_Main_Dive.c Compass_Main_Surface.c Compass_Main_Surface_Cfg.c Compass_Menu_CALIBRATE.c Compass_Menu_MainPage.c Compass_Menu_MainPage_Cfg.c Compass_Menu_SETDECLIN.c Compass_Menu_SETDECLIN_Cfg.c Compass_RefPoint.c CompassHandle_ReferenceReversDisplay.c CompassHandle_TankPressureDisplay.c ContextCompassMenuCfg.c
    ../UserInterface/GUI/OpcodeHandle/Menu/Device Settings/: ContextDeviceSettingsCfg.c Menu_DeviceSettings_Bluetooth.c Menu_DeviceSettings_Bluetooth_Cfg.c Menu_DeviceSettings_MainPage.c Menu_DeviceSettings_MainPage_Cfg.c Menu_DeviceSettings_ResetSettings.c Menu_DeviceSettings_SampleRate.c Menu_DeviceSettings_SampleRate_Cfg.c Menu_DeviceSettings_Units.c Menu_DeviceSettings_Units_Cfg.c Menu_DeviceSettings_WaterType.c Menu_DeviceSettings_WaterType_Cfg.c Menu_DeviceSettings_WelcomeScreen.c Menu_DeviceSettings_WelcomeScreen_Cfg.c Mode_DeviceSettings_Cfg.c
    ../UserInterface/GUI/OpcodeHandle/Menu/Display Settings/: ContextDisplaySettingsCfg.c Menu_DisplaySettings_Autodim.c Menu_DisplaySettings_Autodim_Cfg.c Menu_DisplaySettings_Brightness.c Menu_DisplaySettings_Brightness_Cfg.c Menu_DisplaySettings_Brightness_CheckAutodim.c Menu_DisplaySettings_FlipScreen.c Menu_DisplaySettings_FlipScreen_Cfg.c Menu_DisplaySettings_GTRLeftRight.c Menu_DisplaySettings_GTRLeftRight_Cfg.c Menu_DisplaySettings_Language.c Menu_DisplaySettings_Language_Cfg.c Menu_DisplaySettings_MainDisplay_3rdRowLeft.c Menu_DisplaySettings_MainDisplay_3rdRowLeft_Cfg.c Menu_DisplaySettings_MainDisplay_3rdRowRight.c Menu_DisplaySettings_MainDisplay_3rdRowRight_Cfg.c Menu_DisplaySettings_MainDisplay_Extralarge.c Menu_DisplaySettings_MainDisplay_Extralarge_Cfg.c Menu_DisplaySettings_MainDisplay_GFBGorN2Bar.c Menu_DisplaySettings_MainDisplay_GFBGorN2Bar_Cfg.c Menu_DisplaySettings_MainDisplay_MainPage.c Menu_DisplaySettings_MainPage.c Menu_DisplaySettings_MainPage_Cfg.c Menu_DisplaySettings_TitlesColor.c Menu_DisplaySettings_TitlesColor_Cfg.c Mode_DisplaySettings_Cfg.c
    ../UserInterface/GUI/OpcodeHandle/Menu/Dive Main Menu/: ContextDiveMainMenuCfg.c DiveMainMenuHandle_MainPage.c Menu_DiveMainMenu_Context.c Mode_DiveMainMenu_Cfg.c
    ../UserInterface/GUI/OpcodeHandle/Menu/Dive Menu/: ContextDiveMenuCfg.c DiveMenuHandle_MainPage.c Menu_DiveMenu_ConditionCheck.c Menu_DiveMenu_Context.c Mode_DiveMenu_Cfg.c
    ../UserInterface/GUI/OpcodeHandle/Menu/Dive Planner/: ContextDivePlannerCfg.c Menu_DivePlanner_Context_DepthLimits.c Menu_DivePlanner_Context_Main.c Menu_DivePlanner_Page_DepthLimits.c Menu_DivePlanner_Page_Main.c Menu_DivePlanner_Page_TimeLimits.c Menu_DiveSim_Depth.c Menu_DiveSim_Depth_Context.c Menu_DiveSim_MainPage.c Menu_DiveSim_MainPage_Context.c Menu_DiveSim_NewOrContinuous.c Menu_DiveSim_NewOrContinuous_Context.c Menu_DiveSim_Sac.c Menu_DiveSim_Sac_Context.c Menu_DiveSim_SimulateDive Context.c Menu_DiveSim_SimulateDive.c Menu_DiveSim_SimulateDive_ButtonHandle.c Menu_DiveSim_Sp.c Menu_DiveSim_Sp_Context.c Menu_DiveSim_Time.c Menu_DiveSim_Time_Context.c MenuHandle_DivePlanner_TimeLimitsTittleCheck.c Mode_DivePlanner_Cfg.c
    ../UserInterface/GUI/OpcodeHandle/Menu/Dive Settings/: ContextDiveSettingsCfg.c Menu_DiveSettings_BailOutPO2Limit_Cfg.c Menu_DiveSettings_BailOutPO2Limit_DECO.c Menu_DiveSettings_BailOutPO2Limit_DECO_Cfg.c Menu_DiveSettings_BailOutPO2Limit_MainPage.c Menu_DiveSettings_BailOutPO2Limit_MAX.c Menu_DiveSettings_BailOutPO2Limit_MAX_Cfg.c Menu_DiveSettings_BailOutPO2Limit_MIN.c Menu_DiveSettings_BailOutPO2Limit_MIN_Cfg.c Menu_DiveSettings_Conservatism_SPORT.c Menu_DiveSettings_Conservatism_SPORT_Cfg.c Menu_DiveSettings_Conservatism_TEC_Cfg.c Menu_DiveSettings_Conservatism_TEC_HIGH.c Menu_DiveSettings_Conservatism_TEC_HIGH_Cfg.c Menu_DiveSettings_Conservatism_TEC_LOW.c Menu_DiveSettings_Conservatism_TEC_LOW_Cfg.c Menu_DiveSettings_Conservatism_TEC_MainPage.c Menu_DiveSettings_LastStopDepth.c Menu_DiveSettings_MainPage.c Menu_DiveSettings_MainPage_Cfg.c Menu_DiveSettings_SafetyStop.c Menu_DiveSettings_SafetyStop_Cfg.c Menu_DiveSettings_SetDiveMode.c Menu_DiveSettings_SetDiveMode_Cfg.c Mode_DiveSettings_Cfg.c
    ../UserInterface/GUI/OpcodeHandle/Menu/Gas Switch/: ContextGasSwitchCfg.c Menu_GasSwitch.c Menu_GasSwitch_ConditionCheck.c Menu_GasSwitch_Context.c
    ../UserInterface/GUI/OpcodeHandle/Menu/Main Menu/: ContextMainMenuCfg.c Menu_MainMenu.c Menu_MainMenu_Context.c Mode_MainMenu_Cfg.c
    ../UserInterface/GUI/OpcodeHandle/Menu/Set Alarms/: ContextSetAlarmsCfg.c Menu_SetAlarms.c Menu_SetAlarmsContext.c Mode_SetAlarms_Cfg.c
    ../UserInterface/GUI/OpcodeHandle/Menu/Set Date and Time/: ContextSetDateAndTimeCfg.c Menu_DateAndTime_Date.c Menu_DateAndTime_Date_Cfg.c Menu_DateAndTime_DateFormat.c Menu_DateAndTime_DateFormat_Cfg.c Menu_DateAndTime_MainPage.c Menu_DateAndTime_MainPage_Cfg.c Menu_DateAndTime_Time.c Menu_DateAndTime_Time_Cfg.c Menu_DateAndTime_TimeFormat.c Menu_DateAndTime_TimeFormat_Cfg.c
    ../UserInterface/GUI/OpcodeHandle/Menu/Set Gases/: ContextSetGasesCfg.c Menu_SetGases_Context_GetData.c Menu_SetGases_Context_Main.c Menu_SetGases_Context_OnOffSet.c Menu_SetGases_Context_SetFHe.c Menu_SetGases_Context_SetFO2.c Menu_SetGases_Context_SetTMT.c Menu_SetGases_Page_Main.c Menu_SetGases_Page_SetFHe.c Menu_SetGases_Page_SetFO2.c Menu_SetGases_Page_SetOnOffSet.c Menu_SetGases_Page_SetTMT.c Menu_SetGases_Page_Warning_FHe.c Menu_SetGases_Page_Warning_SetGasOff.c Menu_SetGases_Page_Warning_TMT.c Mode_SetGases_Cfg.c
    ../UserInterface/GUI/OpcodeHandle/Menu/Set Menu/: ContextSetMenuCfg.c Menu_SetMenu.c Menu_SetMenu_Cfg.c Mode_SetMenu_Cfg.c
    ../UserInterface/GUI/OpcodeHandle/Menu/Set SP/: ContextSetSPCfg.c Menu_SetSP_AutoHigh.c Menu_SetSP_AutoHigh_Cfg.c Menu_SetSP_AutoLow.c Menu_SetSP_AutoLow_Cfg.c Menu_SetSP_CustomSP.c Menu_SetSP_CustomSP_Cfg.c Menu_SetSP_HighSP.c Menu_SetSP_HighSP_Cfg.c Menu_SetSP_LowSP.c Menu_SetSP_LowSP_Cfg.c Menu_SetSP_MainPage.c Menu_SetSP_MainPage_Cfg.c
    ../UserInterface/GUI/OpcodeHandle/Menu/SP Switch/: ContextSPSwitchCfg.c Menu_SPSwitch.c Menu_SPSwitch_Cfg.c
    ../UserInterface/GUI/OpcodeHandle/Dive Mode/: DepthAndDiveTimeHandle_AlarmArrowUpDown.c DepthAndDiveTimeHandle_AlarmInBottom.c DepthAndDiveTimeHandle_PressureDisplay.c DepthAndDiveTimeMode_PageMain.c DiveAlarmHandle_AscentTooFast.c DiveAlarmHandle_AutoSwitchingSP_High.c DiveAlarmHandle_AutoSwitchingSP_Low.c DiveAlarmHandle_BatteryShutDown.c DiveAlarmHandle_CC6Pressure.c DiveAlarmHandle_ConditionalViolation.c DiveAlarmHandle_DecoAlarm.c DiveAlarmHandle_DecoEntry.c DiveAlarmHandle_DecoPO2.c DiveAlarmHandle_DecoWarning.c DiveAlarmHandle_DepthAlarm.c DiveAlarmHandle_DiveTimeAlarm.c DiveAlarmHandle_DTR_Alarm.c DiveAlarmHandle_EndP.c DiveAlarmHandle_EquivalentNarcoticDepth.c DiveAlarmHandle_FullViolation.c DiveAlarmHandle_GasSwitch.c DiveAlarmHandle_GasTimeRemaining.c DiveAlarmHandle_GF_90.c DiveAlarmHandle_GradientFactor.c DiveAlarmHandle_HighPO2.c DiveAlarmHandle_LostTMT.c DiveAlarmHandle_LowBattery.c DiveAlarmHandle_LowPO2.c DiveAlarmHandle_MainPage_ArrowUpDown.c DiveAlarmHandle_MainPage_BottomAlarms.c DiveAlarmHandle_MainPage_SwitchTankArrow.c DiveAlarmHandle_MainPage_Violation.c DiveAlarmHandle_N2Bar80.c DiveAlarmHandle_O2Sat.c DiveAlarmHandle_O2SatWarning.c DiveAlarmHandle_OCmaxPO2.c DiveAlarmHandle_OCminPO2.c DiveAlarmHandle_SwitchTank.c DiveAlarmHandle_TankPressure.c DiveAlarmHandle_TimeToSurface.c DiveAlarmHandle_TMTLowBattery.c DiveAlarmHandle_TurnP.c DiveAlarmHandle_WorkOfBreathing.c DiveMode_CC_PageAlt3.c DiveMode_CC_PageAlt5.c DiveMode_CC_PageMain.c DiveMode_Cfg.c DiveMode_Context.c DiveMode_Gauge_MainPage.c DiveMode_Gauge_PageAlt1.c DiveMode_GSM_PageMain.c DiveMode_OC_PageAlt1.c DiveMode_OC_PageAlt2.c DiveMode_OC_PageAlt3.c DiveMode_OC_PageAlt4.c DiveMode_OC_PageAlt5.c DiveMode_OC_PageMain.c DiveMode_SM_PageAlt1.c DiveMode_SM_PageAlt2.c DiveMode_SM_PageAlt3.c DiveMode_SM_PageAlt4.c DiveMode_SM_PageAlt5.c DiveMode_SM_PageMain.c DiveModeHandle_BatteryDisplayCheck.c DiveModeHandle_CC_DisplayContentInMiddle.c DiveModeHandle_ClearPortionScreen.c DiveModeHandle_Deco_NoDeco_DeepStop_SafetyStop.c DiveModeHandle_DisplayExtralargeDepthOrDiveTime.c DiveModeHandle_DisplayGTR.c DiveModeHandle_DisplayImperialOrMetric.c DiveModeHandle_GSM_CheckDisplayWhenViolation.c DiveModeHandle_In10MinsAfterDive.c DiveModeHandle_MainFO2Display.c DiveModeHandle_SM_DisplayContentInMiddle.c
    ../UserInterface/GUI/OpcodeHandle/Menu/Dive Main Menu/Dive Profile Graph/: DiveMainMenuHandle_DiveProfileGraph.c
    ../UserInterface/GUI/OpcodeHandle/WarningAndErrorMsgs/: Error_Warning_Pages.c Error_Warning_Pages_Cfg.c
    ../UserInterface/GUI/OpcodeHandle/WelcomeScreen/: ManufacturingScreen.c RegisterScreen.c WelcomeScreen.c
    ../UserInterface/GUI/OpcodeHandle/Menu/Device Settings/Transmitter Settings/: Menu_DeviceSettings_Transmitter_MainPage.c Menu_DeviceSettings_Transmitter_MainPage_Cfg.c Menu_DeviceSettings_Transmitter_TMT_1.c Menu_DeviceSettings_Transmitter_TMT_1_Cfg.c Menu_DeviceSettings_Transmitter_TMT_2.c Menu_DeviceSettings_Transmitter_TMT_2_Cfg.c Menu_DeviceSettings_Transmitter_TMT_3.c Menu_DeviceSettings_Transmitter_TMT_3_Cfg.c Menu_DeviceSettings_Transmitter_TMT_4.c Menu_DeviceSettings_Transmitter_TMT_4_Cfg.c Menu_DeviceSettings_Transmitter_TMT_5.c Menu_DeviceSettings_Transmitter_TMT_5_Cfg.c Menu_DeviceSettings_Transmitter_TMT_6.c Menu_DeviceSettings_Transmitter_TMT_6_Cfg.c
    ../UserInterface/GUI/OpcodeHandle/Menu/Main Menu/Main_Menu_INFO/: Menu_MainMenu_Info.c Menu_MainMenu_Info_Cfg.c Menu_MainMenu_Info_Context.c Menu_MainMenu_Info_DSXINFO.c Menu_MainMenu_Info_HISTORY.c Menu_MainMenu_Info_MYINFO.c MenuHandle_MyInfo_ReadEepromData.c
    ../UserInterface/GUI/OpcodeHandle/Menu/Main Menu/Main_Menu_Slates/: Menu_MainMenu_Slates.c Menu_MainMenu_Slates_ButtonHandle.c Menu_MainMenu_Slates_Context.c
    ../UserInterface/GUI/OpcodeHandle/Menu/Set Alarms/Set Alarms Audible Virbration/: Menu_SetAlarms_AudibleVibration_Audible.c Menu_SetAlarms_AudibleVibration_Audible_Cfg.c Menu_SetAlarms_AudibleVibration_Cfg.c Menu_SetAlarms_AudibleVibration_MainPage.c Menu_SetAlarms_AudibleVibration_Vibaration.c Menu_SetAlarms_AudibleVibration_Vibaration_Cfg.c
    ../UserInterface/GUI/OpcodeHandle/Menu/Set Alarms/Set Alarms CC6 Press/: Menu_SetAlarms_CC6Press.c Menu_SetAlarms_CC6Press_Cfg.c
    ../UserInterface/GUI/OpcodeHandle/Menu/Set Alarms/Set Alarms Depth/: Menu_SetAlarms_DEPTH.c Menu_SetAlarms_DEPTH_Cfg.c
    ../UserInterface/GUI/OpcodeHandle/Menu/Set Alarms/Set Alarms Dive Time TTS/: Menu_SetAlarms_DiveTimeTTS_Context.c Menu_SetAlarms_DiveTimeTTS_DiveTime.c Menu_SetAlarms_DiveTimeTTS_MainPage.c Menu_SetAlarms_DiveTimeTTS_TTS.c
    ../UserInterface/GUI/OpcodeHandle/Menu/Set Alarms/Set Alarms DTR/: Menu_SetAlarms_DTR.c Menu_SetAlarms_DTR_Cfg.c
    ../UserInterface/GUI/OpcodeHandle/Menu/Set Alarms/SetAlarms_EndWobIcd/: Menu_SetAlarms_EndWobIcd.c Menu_SetAlarms_EndWobIcd_Cfg.c Menu_SetAlarms_EndWobIcd_Context.c Menu_SetAlarms_EndWobIcd_End.c Menu_SetAlarms_EndWobIcd_Icd.c Menu_SetAlarms_EndWobIcd_O2Narcotic.c Menu_SetAlarms_EndWobIcd_Wob.c
    ../UserInterface/GUI/OpcodeHandle/Menu/Set Alarms/Set Alarms GF N2/: Menu_SetAlarms_GFN2.c Menu_SetAlarms_GFN2_Context.c
    ../UserInterface/GUI/OpcodeHandle/Menu/Set Alarms/Set Alarms Tank Press/: Menu_SetAlarms_TankPress.c Menu_SetAlarms_TankPress_Context.c
    ../UserInterface/GUI/OpcodeHandle/Menu/Set Alarms/SetAlarms_TurnEndPress/: Menu_SetAlarms_TurnEndSwitchPress.c Menu_SetAlarms_TurnEndSwitchPress_Cfg.c Menu_SetAlarms_TurnEndSwitchPress_Context.c Menu_SetAlarms_TurnEndSwitchPress_END.c Menu_SetAlarms_TurnEndSwitchPress_SWITCH.c Menu_SetAlarms_TurnEndSwitchPress_TURN.c
  group UserInterface/GUI/TTF_Engine
    ../Libraries/Middleware/STemWin/V544/truetype/: afangles.h afblue.h afcjk.h afcover.h afdummy.h aferrors.h afglobal.h afhints.h afindic.h aflatin.h aflatin2.h afloader.h afmodule.h afmparse.h afpic.h afranges.h afscript.h afstyles.h aftypes.h afwarp.h afwrtsys.h autofit.c autohint.h basepic.h bdf.c bdf.h bdfdrivr.h bdferror.h cf2arrst.h cf2blues.h cf2error.h cf2fixed.h cf2font.h cf2ft.h cf2glue.h cf2hints.h cf2intrp.h cf2read.h cf2stack.h cf2types.h cff.c cffcmap.h cffdrivr.h cfferrs.h cffgload.h cffload.h cffobjs.h cffparse.h cffpic.h cfftoken.h cfftypes.h ciderrs.h cidgload.h cidload.h cidobjs.h cidparse.h cidriver.h cidtoken.h fnterrs.h freetype.h ft2build.h ftadvanc.h ftautoh.h ftbase.c ftbase.h ftbbox.c ftbbox.h ftbdf.c ftbdf.h ftbitmap.c ftbitmap.h ftbzip2.c ftbzip2.h ftcache.c ftcache.h ftcalc.h ftccache.h ftccback.h ftcerror.h ftcffdrv.h ftcglyph.h ftchapters.h ftcid.c ftcid.h ftcimage.h ftcmanag.h ftcmru.h ftconfig.h ftcsbits.h ftdebug.c ftdebug.h ftdriver.h fterrdef.h fterrors.h ftfstype.c ftgasp.c ftgasp.h ftgloadr.h ftglyph.c ftglyph.h ftgrays.h ftgxval.c ftgxval.h ftgzip.c ftgzip.h ftheader.h ftimage.h ftincrem.h ftinit.c ftlcdfil.c ftlcdfil.h ftlist.h ftlzw.c ftlzw.h ftmac.h ftmemory.h ftmisc.h ftmm.c ftmm.h ftmodapi.h ftmoderr.h ftmodule.h ftobjs.h ftoption.h ftotval.c ftotval.h ftoutln.h ftpatent.c ftpfr.c ftpfr.h ftpic.h ftraster.h ftrend1.h ftrender.h ftrfork.h ftserv.h ftsizes.h ftsmerrs.h ftsmooth.h ftsnames.h ftspic.h ftstdlib.h ftstream.h ftstroke.c ftstroke.h ftsynth.c ftsynth.h ftsystem.c ftsystem.h fttrace.h fttrigon.h ftttdrv.h fttype1.c fttypes.h ftvalid.h ftwinfnt.c ftwinfnt.h ftxf86.c ftxf86.h ftzopen.h GUI_TTF.c gxvalid.c gxvalid.h gxvcommn.h gxverror.h gxvfeat.h gxvmod.h gxvmort.h gxvmorx.h hbshim.h infblock.h infcodes.h infutil.h internal.h md5.h otvalid.c otvalid.h otvcommn.h otverror.h otvgpos.h otvmod.h pcf.c pcf.h pcfdrivr.h pcferror.h pcfread.h pcfutil.h pfr.c pfrcmap.h pfrdrivr.h pfrerror.h pfrgload.h pfrload.h pfrobjs.h pfrsbit.h pfrtypes.h pngshim.h psaux.c psaux.h psauxerr.h psauxmod.h psconv.h pshalgo.h pshglob.h pshinter.c pshints.h pshmod.h pshnterr.h pshpic.h pshrec.h psmodule.h psnamerr.h psnames.c psobjs.h pspic.h pstables.h raster.c rasterrs.h rastpic.h sfdriver.h sferrors.h sfnt.c sfnt.h sfntpic.h sfobjs.h smooth.c svbdf.h svcid.h svgldict.h svgxval.h svkern.h svmm.h svotval.h svpfr.h svpostnm.h svprop.h svpscmap.h svpsinfo.h svsfnt.h svttcmap.h svtteng.h svttglyf.h svwinfnt.h svxf86nm.h t1afm.h t1cmap.h t1decode.h t1driver.h t1errors.h t1gload.h t1load.h t1objs.h t1parse.h t1tables.h t1tokens.h t1types.h t42drivr.h t42error.h t42objs.h t42parse.h t42types.h truetype.c ttbdf.h ttcmap.h ttcmapc.h ttdriver.h tterrors.h ttgload.h ttgxvar.h ttinffixed.h ttinftrees.h ttinterp.h ttkern.h ttload.h ttmtx.h ttnameid.h ttobjs.h ttpic.h ttpload.h ttpost.h ttsbit.h ttsubpix.h tttables.h tttags.h tttypes.h ttunpat.h ttzconf.h ttzlib.h ttzutil.h type1.c type1cid.c type42.c winfnt.c winfnt.h
